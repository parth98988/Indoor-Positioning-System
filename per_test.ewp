# IAR project per_test.ewp, settings and files
configuration Debug on CC2510 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2510.i51
  ICC8051.CCDefines: chip=2510
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CODE\PER_TEST\INCLUDE; ..\CODE\LIBRARY\HAL\INCLUDE; ..\CODE\LIBRARY\HAL_BUI\INCLUDE
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  A8051.ADefines: chip=2510
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2510F32.xcl
configuration Build .hex for CC2510 (8051)
  as the first configuration, except:
  group (top)
    ../source/components/common/cc8051/: hal_cc8051.h
    ../source/components/common/: hal_defs.h hal_types.h
    ../source/components/radio/ccxx10/: ioCCxx10_bitdef.h
    ../code/PER_test/source/: per_test_dma.c per_test_main.c per_test_menu.c per_test_radio.c
    ../code/PER_test/source/util/: util_lcd_logo.c
  group hal
    ../code/Library/HAL/source/: hal_adc_mgmt.c hal_power_clk_mgmt.c hal_wait.c
  group hal_bui
    ../code/Library/HAL_BUI/source/: hal_bui_button.c hal_bui_joystick.c hal_bui_lcd.c
